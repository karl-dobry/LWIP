# Keil uVision project LWIP.uvprojx, settings and files
target LWIP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: LWIP
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;   ../Middlewares/Third_Party/LwIP/src/include;   ../Middlewares/Third_Party/LwIP/system;   ../Drivers/STM32F7xx_HAL_Driver/Inc;   ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;   ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Middlewares/Third_Party/LwIP/src/include/lwip;   ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;   ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;   ../Middlewares/Third_Party/LwIP/src/include/netif;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;   ../Middlewares/Third_Party/LwIP/src/include/posix;   ../Middlewares/Third_Party/LwIP/src/include/posix/sys;   ../Middlewares/Third_Party/LwIP/system/arch;   ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c event_groups.c timers.c croutine.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c ip4.c ip_frag.c icmp.c igmp.c
    ../Middlewares/Third_Party/LwIP/src/core/: pbuf.c memp.c netif.c init.c tcp_in.c inet_chksum.c tcp_out.c stats.c tcp.c def.c udp.c mem.c dns.c sys.c lwip_timers.c raw.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipcp.c lcp.c chap-md5.c pppcrypt.c auth.c chap-new.c magic.c chap_ms.c ecp.c eap.c pppos.c ccp.c mppe.c upap.c multilink.c vj.c pppoe.c ipv6cp.c demand.c eui64.c pppol2tp.c utils.c fsm.c ppp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: arc4.c sha1.c md5.c md4.c des.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ip6_frag.c ethip6.c ip6.c icmp6.c nd6.c inet6.c ip6_addr.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c api_lib.c netdb.c err.c pppapi.c sockets.c tcpip.c api_msg.c netifapi.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/User
    ../Src/: ethernetif.c stm32f7xx_it.c main.c stm32f7xx_hal_msp.c lwip.c freertos.c stm32f7xx_hal_timebase_TIM.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma.c
software components: CMSIS:CORE 4.1.0
